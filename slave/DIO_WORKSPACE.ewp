# IAR project DIO_WORKSPACE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: can.c can.h main.c startup_ewarm.c
  group APPAL/APP/inc
    APPAL/APP/inc/: APP.h
  group APPAL/APP/src
    APPAL/APP/src/: APP.c
  group APPAL/OS/config
    APPAL/OS/config/: OS_Cfg.c
  group APPAL/OS/inc
    APPAL/OS/inc/: OS.h OS_Cfg.h
  group APPAL/OS/src
    APPAL/OS/src/: OS.c
  group HAL/BUTTON/inc
    HAL/BUTTON/inc/: Button.h
  group HAL/BUTTON/src
    HAL/BUTTON/src/: Button.c
  group HAL/LED/inc
    HAL/LED/inc/: LED.h
  group HAL/LED/src
    HAL/LED/src/: LED.c
  group MCAL/CAN/inc
    MCAL/CAN/inc/: CAN_INIT.h
  group MCAL/CAN/src
    MCAL/CAN/src/: CAN_INIT.c
  group MCAL/DIO/config
    MCAL/DIO/config/: Dio_Lcfg.c
  group MCAL/DIO/inc
    MCAL/DIO/inc/: Dio.h Dio_Cfg.h
  group MCAL/DIO/src
    MCAL/DIO/src/: Dio.c
  group MCAL/PORT/config
    MCAL/PORT/config/: Port_PBcfg.c
  group MCAL/PORT/inc
    MCAL/PORT/inc/: Port.h Port_Cfg.h Port_REG.h
  group MCAL/PORT/src
    MCAL/PORT/src/: Port.c
  group MCAL/SYSTICK_TIMER/inc
    MCAL/SYSTICK_TIMER/inc/: systick.h
  group MCAL/SYSTICK_TIMER/src
    MCAL/SYSTICK_TIMER/src/: systick.c
  group services
    services/: Common_macros.h Compiler.h Platform_Types.h Std_Types.h tm4c123gh6pm_registers.h
